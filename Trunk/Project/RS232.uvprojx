# Keil uVision project RS232.uvprojx, settings and files
target Traget (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS232_A +hex
  c flags: Optim=1
  c include: ..\Core;..\Lib_code\SysLib\inc;..\Lib_code\SysHard\inc;..\Lib_code\App;..\User\IR;..\User\IRDirver;..\User\ExactDelay;..\User\Buzzer;..\User
  memory RVCT4: ROM 0x8000800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Core/: system_stm32f10x.c startup_stm32f10x_md.s
  group SysLib
    ../Lib_code/SysLib/: AttrEncrypt .c BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c DlyAttrProcess.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c Linksimplest.c LinksimplestTime.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c Sign433.c Sign433Attr.c SysExeAttr.c SysTestAttr.c Thread.c TimeHandle.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c Encode_lib.lib
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c FlashSizeFlag.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
  group Drive
    ../User/: USARTx.c
  group Unit
    ../User/: RS232Unit.c
  group Attr
    ../User/: RS232Attr.c
